# Keil uVision project TrafficLight.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TrafficLight +hex
  AfterMake: fromelf --m32 --output=C:\Users\Nick\Documents\KeilProject\TrafficLight\Objects\object.srec C:\Users\Nick\Documents\KeilProject\TrafficLight\Objects\TrafficLight.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.s
